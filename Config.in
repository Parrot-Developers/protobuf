## Config.in
```kconfig
config PROTOBUF_PACKAGE_PROTOC
        bool "use alchemy built protoc for .proto compilation"
        default y
```
